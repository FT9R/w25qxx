# IAR project w25qxx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; HSE_VALUE=8000000; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Config; Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\Delay; Libraries\SPI; Libraries\w25qxx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Config
    Config/: startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h Sys_Init.c Sys_Init.h system_stm32f4xx.c system_stm32f4xx.h
  group Include
    Include/: Init.h main.h
  group Libraries/Delay
    Libraries/Delay/: Delay.c Delay.h
  group Libraries/SPI
    Libraries/SPI/: SPI.c SPI.h
  group Libraries/STM32F4xx_StdPeriph_Driver/inc
    Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_flash.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_spi.h
  group Libraries/STM32F4xx_StdPeriph_Driver/src
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c
  group Libraries/w25qxx
    Libraries/w25qxx/: w25qxx.c w25qxx.h w25qxx_Interface.c w25qxx_Interface.h
  group Source
    Source/: Init.c main.c
